# Keil uVision project main_keil.uvproj, settings and files
target main (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: main_keil +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\public;.\user;.\apps\lcd1602;.\apps\ad7705;.\apps\key;.\apps\switch;.\apps\diode;.\apps\spline
  group user
    ./user/: main.c progess.c ui.c
  group apps
    ./apps/lcd1602/: lcd1602.c
    ./apps/ad7705/: ad7705.c
    ./apps/key/: key.c
    ./apps/switch/: switch.c
    ./apps/diode/: diode.c
    ./apps/spline/: spline.c
  group public
    ./public/: public.c
